Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 3bc9720e-1039-4fb0-8913-15054eb691cd, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Gemeinsam genutzte Koordinaten]
File name: INTEGRA UNILINE 300.ifc
Time: 2025-01-29T11:56:27+01:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.1.0.44 (DEU) - IFC 25.1.0.44

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: INTEGRA UNILINE 300:INTEGRA UNILINE, INTEGRA UNILINE 300:INTEGRA UNILINE:2518107
In: Default
Type - Material: Vorgabe_1
Type - Pset_ElementShading - Color: white
Pset_DistributionFlowElementCommon - Reference: INTEGRA UNILINE; sets with these values: 2
